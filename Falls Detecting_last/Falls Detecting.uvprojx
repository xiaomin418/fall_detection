# Keil uVision project Falls Detecting.uvprojx, settings and files
target Falls Detecting (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0VLL12 NXP
  pack: NXP.MK64F12_DFP.10.0.4
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Falls Detecting
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VLL12, FRDM_K64F, FREEDOM
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .\board;.\inc;.\utilities;.\src;.\core;.\drivers;..\Falls Detecting
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: .\MK64FN1M0xxx12_flash.scf
  link misc: --remove
  group Board
    ./board/: board.c clock_config.c pin_mux.c board.h clock_config.h pin_mux.h pit.c cmsis_usart_interrupt_transfer.c cmsis_usart.h RTE_Device.h gpio_input_interrupt.c
  group users
    ./src/: main.c delay.c global.c gpio.c LED.c MPU9250.c MPUIIC.c analysis.c analysis.h
  group Drivers
    ./drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_gpio.c fsl_gpio.h fsl_pit.c fsl_pit.h fsl_port.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h fsl_dmamux.c fsl_edma.c fsl_uart_cmsis.c fsl_uart_edma.c
  group Utilities
    ./utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h fsl_io.c fsl_io.h fsl_log.c fsl_log.h fsl_str.c fsl_str.h
  group Core
    ./core/: system_MK64F12.c system_MK64F12.h startup_MK64F12.s
